# Keil uVision project PTZ_Camera2.uvprojx, settings and files
target PTZ_Camera2 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32G431RBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: PTZ_Camera2 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Application/User/PTZ
    ../Core/Src/: application.c control.c motor.c k230_link.c vision_control.c uart_dispatch.c
    ../Core/Inc/: app_config.h application.h control.h motor.h k230_link.h vision_control.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_cortex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 4.3.0
